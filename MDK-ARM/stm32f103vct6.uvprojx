# Keil uVision project stm32f103vct6.uvprojx, settings and files
target stm32f103vct6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103vct6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;                                            ../USB_DEVICE/App;                                            ../USB_DEVICE/Target;                                            ../Drivers/STM32F1xx_HAL_Driver/Inc;                                            ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                                            ../Middlewares/Third_Party/FreeRTOS/Source/include;                                            ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;                                            ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                            ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;                                            ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                                            ../Drivers/CMSIS/Include;                                            ..\Source\App;                                            ..\Source\common;                                            ..\Source\Sch;                                            ..\Source\SigmaStudio_Dsp;                               ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c rtc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_custom_hid_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group Source
    ../Source/App/: app_ad1938.c app_amp.c app_at.c app_bt.c app_connect.c app_debug.c app_dsp_adau1452.c app_dsp_driver.c app_dsp_eq.c app_dsp_filter.c app_dsp_mix.c app_dsp_readback.c app_dsp_single_mute.c app_dspdata_access.c app_eprom.c app_led.c app_lowpower.c app_mute.c app_power.c app_start.c app_task.c app_tdf8541.c app_updata.c app_voltage.c bsp.c interrupt.c mw_adc.c mw_flash.c mw_gpio.c mw_i2c.c mw_rtc.c mw_spi.c mw_time.c mw_uart.c system.c
    ../Source/common/: assert.c memtest.c queue.c
    ../Source/Sch/: sch_common.c sch_message.c sch_printf.c sch_queue.c
software components: CMSIS:CORE 4.3.0
